** sch_path: testbenches/xschem/chip_top_tb_tran.sch
**.subckt chip_top_tb_tran
VDD VDD GND {VDD}
vclk clock GND pulse(0 {IOVDD} 0 100p 100p {0.5/fclk} {1/fclk})
vrst reset_n GND pulse({IOVDD} 0 {2/fclk} 100p 100p {2/fclk} 1 1)
VIO VIO GND {IOVDD}
x1 counter1_value5_inv1_din2 counter1_value4_inv1_din1 counter1_value7_inv1_din4
+ counter1_value6_inv1_din3 clock reset_n enable inv2_vout2 inv2_vout1 inv2_vin2 inv2_vin1 counter1_value0 counter1_value1
+ counter1_value2 counter1_value3 GND VIO GND VDD sram_0_out counter2_value0 counter2_value1 counter2_value2
+ counter2_value3 counter2_value4 counter2_value5 counter2_value6 counter2_value7 inv1_dout1 inv1_dout2 inv1_dout3
+ inv1_dout4 chip_top
Venable enable GND pulse({IOVDD} 0 {100/fclk} 100p 100p {100/fclk} 1 1)
vsine1 inv2_vin1 GND sin({Vcm} 10m 200k)
vsine2 inv2_vin2 GND sin({Vcm} 10m 400k)
**** begin user architecture code


*.include ../../../verification/pex/chip_top_pex.spice
.include ../../../macros/counter/netlist/xspice/counter_top.xspice
.param IOVDD=3.3
.param VDD=1.5
.param Vcm=0.75
.temp 27
.param Cload=10p
.param Rload=1k
.param fclk=50e6
.csparam fclk=fclk
.options klu method=gear reltol=3e-3 vntol=1e-5 abstol=1e-11 chgtol=1e-11 cshunt=100f rshunt=1e15
.control

set num_threads=32

save all

* User Constants
let tstart = 0
let tstop = 10u
let tstep = 100n

* Transient Operating Point Analysis
*optran 0 0 0 $&tstep $&tstart 0
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran $&tstep $&tstop $&tstart
write @schname\.raw

* Plotting
plot clock reset_n enable sram_0_out
plot inv2_vin1 inv2_vout1 inv2_vin2 inv2_vout2
plot inv1_dout1 inv1_dout2 inv1_dout3 inv1_dout4
plot counter2_value0 counter2_value1 counter2_value2 counter2_value3 counter2_value4 counter2_value5
+ counter2_value6 counter2_value7
plot counter1_value4_inv1_din1 counter1_value5_inv1_din2

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/chip_top_tb_tran.txt  v(clock) v(reset_n) v(enable) v(sram_0_out)
+  v(inv2_vin1) v(inv2_vout1) v(inv2_vin2) v(inv2_vout2)  v(inv1_dout1) v(inv1_dout2) v(inv1_dout3) v(inv1_dout4)
+  v(counter2_value0) v(counter2_value1) v(counter2_value2) v(counter2_value3)  v(counter2_value4) v(counter2_value5)
+ v(counter2_value6) v(counter2_value7)  v(counter1_value4_inv1_din1) v(counter1_value5_inv1_din2)

*quit
*rusage all
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib ../models/cornerDIO_custom.lib dio_tt



* Repo copy of the pad netlist, the one LibreLane and cocotb use.
* On SG13CMOS5L it equals the PDK sg13cmos5l_io.spi, and its
* subcircuit pin order matches the PDK Xschem pad symbols
* (vss vdd iovss iovdd ...).
.include ../../../ip/sg13cmos5l_io_custom/spice/sg13cmos5l_io.spi



.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
