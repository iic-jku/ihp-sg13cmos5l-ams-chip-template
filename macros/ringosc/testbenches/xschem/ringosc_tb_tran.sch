** sch_path: macros/ringosc/testbenches/xschem/ringosc_tb_tran.sch
**.subckt ringosc_tb_tran
VDD VDD GND {VDD}
C1 vout GND {Cload} m=1
x1 vout VDD GND ringosc
**** begin user architecture code


.include ../../../netlist/pex/ringosc_magic_pex_3.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.csparam Vcm=Vcm
.temp 27
.param Cload=100f
.param Rload=1k
.options savecurrents reltol=1e-3 abstol=1e-12 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
*tran 100p 5u 2u
tran 100p 2.55u 2.54u
write @schname\.raw

* Plotting
plot vout
plot i(VDD)

* Measurements
* Oscillation frequency from two consecutive rising crossings of the mid-level Vcm.
* The stored transient window has to contain at least two rising edges.
meas tran t_rise1 when v(vout)=Vcm rise=1
meas tran t_rise2 when v(vout)=Vcm rise=2
let T_osc = t_rise2 - t_rise1
let f_osc = 1/T_osc
print T_osc
print f_osc

* Stage delay of the three-stage ring, T_osc = 2 * N * t_d with N = 3
let t_d = T_osc/6
print t_d

* Output swing
meas tran vout_max MAX v(vout)
meas tran vout_min MIN v(vout)
let vout_pp = vout_max - vout_min
print vout_pp

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt v(vout)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
