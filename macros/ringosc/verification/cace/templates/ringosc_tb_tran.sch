** sch_path: macros/ringosc/verification/cace/templates/ringosc_tb_tran.sch
**.subckt ringosc_tb_tran
C2 vout GND CACE{cload} m=1
VDD VDD GND CACE{vdd}
VSS VSS GND 0
x1 vout VDD GND ringosc
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
* Start-up: the operating point holds vosc low, so the ring does not wait at its mid-rail point for numerical noise
.ic v(x1.vosc)=0
.control

save v(vout) i(VDD)

* CACE already runs one ngspice per core
set num_threads=1

* Transient Analysis
tran 10p 200n 0 20p

* Measurements, without two crossings of VDD/2 fosc stays 0 and fails its minimum
let vmid = CACE{vdd}/2
let t_start = 0
let t_stop = 0
let fosc = 0
let Idd = 0
* Skip the start-up, average over 20 periods
meas tran t_start when v(vout)=vmid rise=10
meas tran t_stop when v(vout)=vmid rise=30
if t_stop > t_start
  let fosc = 20/(t_stop-t_start)
  meas tran Idd_avg avg i(VDD) from=$&t_start to=$&t_stop
  let Idd = -Idd_avg
end

echo $&fosc $&Idd > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
