** sch_path: macros/vco/schematic/xschem/vco_ind.sch
**.subckt vco_ind la lc lb VSS
*.iopin la
*.iopin lc
*.iopin lb
*.iopin VSS
x1 la lb lc vco_ind_le
**.ends
.end
