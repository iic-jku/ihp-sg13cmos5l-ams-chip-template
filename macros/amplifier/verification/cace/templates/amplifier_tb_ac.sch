** sch_path: macros/amplifier/verification/cace/templates/amplifier_tb_ac.sch
**.subckt amplifier_tb_ac
C2 vout GND CACE{cload} m=1
VDD VDD GND CACE{vdd}
VSS VSS GND 0
Cc vin vs 1u m=1
x1 VDD vin vout GND amplifier
vs vs GND dc 0 ac 1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control

save all

* CACE already runs one ngspice per core
set num_threads=1

* AC Analysis
ac dec 101 1 1G

* Voltage gain between the macro pins. Cc leaves the DC point to the feedback rhigh, and vout/vin does not depend on what drives vin
let Av=v(vout)/v(vin)
let Av_mag_dB = vdb(Av)

* Measurements
* 10Hz voltage gain
meas ac Av_dB find Av_mag_dB when frequency = 10

* Upper 3dB cut-off frequency
let Amag_fc = Av_dB-3
meas ac fcu find frequency when Av_mag_dB = Amag_fc FALL=1

echo $&Av_dB $&fcu > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
