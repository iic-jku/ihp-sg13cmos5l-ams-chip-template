v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 30 -5140 30 -5190 {lab=VSS}
N 40 -5130 40 -5220 {lab=VDD}
N 50 -5120 50 -5250 {lab=IOVSS}
N 60 -5110 60 -5280 {lab=IOVDD}
N 200 -5150 200 -5360 {lab=clk}
N 110 -4900 110 -4840 {lab=clk_PAD}
N 360 -5140 360 -5190 {lab=VSS}
N 370 -5130 370 -5220 {lab=VDD}
N 380 -5120 380 -5250 {lab=IOVSS}
N 390 -5110 390 -5280 {lab=IOVDD}
N 530 -5150 530 -5360 {lab=rst_n}
N 440 -4900 440 -4840 {lab=rst_n_PAD}
N 690 -5140 690 -5190 {lab=VSS}
N 700 -5130 700 -5220 {lab=VDD}
N 710 -5120 710 -5250 {lab=IOVSS}
N 720 -5110 720 -5280 {lab=IOVDD}
N 860 -5150 860 -5360 {lab=sel1}
N 770 -4900 770 -4840 {lab=input_PAD[1]}
N 1020 -5140 1020 -5190 {lab=VSS}
N 1030 -5130 1030 -5220 {lab=VDD}
N 1040 -5120 1040 -5250 {lab=IOVSS}
N 1050 -5110 1050 -5280 {lab=IOVDD}
N 1190 -5150 1190 -5360 {lab=sel0}
N 1100 -4900 1100 -4840 {lab=input_PAD[0]}
N 1350 -5140 1350 -5190 {lab=VSS}
N 1360 -5130 1360 -5220 {lab=VDD}
N 1370 -5120 1370 -5250 {lab=IOVSS}
N 1380 -5110 1380 -5280 {lab=IOVDD}
N 1430 -4900 1430 -4840 {lab=IOVDD}
N 1680 -5140 1680 -5190 {lab=VSS}
N 1690 -5130 1690 -5220 {lab=VDD}
N 1700 -5120 1700 -5250 {lab=IOVSS}
N 1710 -5110 1710 -5280 {lab=IOVDD}
N 1760 -4900 1760 -4840 {lab=IOVSS}
N 2010 -5140 2010 -5190 {lab=VSS}
N 2020 -5130 2020 -5220 {lab=VDD}
N 2030 -5120 2030 -5250 {lab=IOVSS}
N 2040 -5110 2040 -5280 {lab=IOVDD}
N 2090 -4900 2090 -4840 {lab=VDD}
N 2340 -5140 2340 -5190 {lab=VSS}
N 2350 -5130 2350 -5220 {lab=VDD}
N 2360 -5120 2360 -5250 {lab=IOVSS}
N 2370 -5110 2370 -5280 {lab=IOVDD}
N 2420 -4900 2420 -4840 {lab=VSS}
N -30 -5190 2570 -5190 {lab=VSS}
N -30 -5220 2570 -5220 {lab=VDD}
N -30 -5250 2570 -5250 {lab=IOVSS}
N -30 -5280 2570 -5280 {lab=IOVDD}
N 30 -4340 30 -4390 {lab=VSS}
N 40 -4330 40 -4420 {lab=VDD}
N 50 -4320 50 -4450 {lab=IOVSS}
N 60 -4310 60 -4480 {lab=IOVDD}
N 200 -4350 200 -4560 {lab=di_en}
N 110 -4100 110 -4040 {lab=input_PAD[2]}
N 337.5 -4340 337.5 -4390 {lab=VSS}
N 347.5 -4330 347.5 -4420 {lab=VDD}
N 357.5 -4320 357.5 -4450 {lab=IOVSS}
N 370 -4310 370 -4480 {lab=IOVDD}
N 430 -4350 430 -4560 {lab=analog_PAD[0]}
N 530 -4350 530 -4560 {lab=vtune}
N 440 -4100 440 -4040 {lab=analog_PAD[0]}
N 690 -4340 690 -4390 {lab=VSS}
N 700 -4330 700 -4420 {lab=VDD}
N 710 -4320 710 -4450 {lab=IOVSS}
N 720 -4310 720 -4480 {lab=IOVDD}
N 770 -4100 770 -4040 {lab=VSS}
N 1050 -4120 1010 -4120 {lab=VSS}
N 1050 -4280 1010 -4280 {lab=VDD}
N 1130 -4120 1170 -4120 {lab=IOVSS}
N 1130 -4280 1170 -4280 {lab=IOVDD}
N 1190 -4200 1230 -4200 {lab=rf_PAD[0]}
N 1380 -4120 1340 -4120 {lab=VSS}
N 1380 -4280 1340 -4280 {lab=VDD}
N 1460 -4120 1500 -4120 {lab=IOVSS}
N 1460 -4280 1500 -4280 {lab=IOVDD}
N 1520 -4200 1560 -4200 {lab=rf_PAD[1]}
N 1680 -4340 1680 -4390 {lab=VSS}
N 1690 -4330 1690 -4420 {lab=VDD}
N 1700 -4320 1700 -4450 {lab=IOVSS}
N 1710 -4310 1710 -4480 {lab=IOVDD}
N 1760 -4100 1760 -4040 {lab=VSS}
N 1987.5 -4340 1987.5 -4390 {lab=VSS}
N 1997.5 -4330 1997.5 -4420 {lab=VDD}
N 2007.5 -4320 2007.5 -4450 {lab=IOVSS}
N 2020 -4310 2020 -4480 {lab=IOVDD}
N 2080 -4350 2080 -4560 {lab=vdd_rf_PAD}
N 2180 -4350 2180 -4560 {lab=open_vdd_rf_pad_padres}
N 2090 -4100 2090 -4040 {lab=vdd_rf_PAD}
N 2340 -4340 2340 -4390 {lab=VSS}
N 2350 -4330 2350 -4420 {lab=VDD}
N 2360 -4320 2360 -4450 {lab=IOVSS}
N 2370 -4310 2370 -4480 {lab=IOVDD}
N 2420 -4100 2420 -4040 {lab=VSS}
N -30 -4390 2570 -4390 {lab=VSS}
N -30 -4420 2570 -4420 {lab=VDD}
N -30 -4450 2570 -4450 {lab=IOVSS}
N -30 -4480 2570 -4480 {lab=IOVDD}
N 7.5 -3540 7.5 -3590 {lab=VSS}
N 17.5 -3530 17.5 -3620 {lab=VDD}
N 27.5 -3520 27.5 -3650 {lab=IOVSS}
N 40 -3510 40 -3680 {lab=IOVDD}
N 100 -3550 100 -3760 {lab=analog_PAD[1]}
N 200 -3550 200 -3760 {lab=amp_vin}
N 110 -3300 110 -3240 {lab=analog_PAD[1]}
N 337.5 -3540 337.5 -3590 {lab=VSS}
N 347.5 -3530 347.5 -3620 {lab=VDD}
N 357.5 -3520 357.5 -3650 {lab=IOVSS}
N 370 -3510 370 -3680 {lab=IOVDD}
N 430 -3550 430 -3760 {lab=analog_PAD[2]}
N 530 -3550 530 -3760 {lab=open_amp_vout_pad_padres}
N 440 -3300 440 -3240 {lab=analog_PAD[2]}
N 667.5 -3540 667.5 -3590 {lab=VSS}
N 677.5 -3530 677.5 -3620 {lab=VDD}
N 687.5 -3520 687.5 -3650 {lab=IOVSS}
N 700 -3510 700 -3680 {lab=IOVDD}
N 760 -3550 760 -3760 {lab=analog_PAD[3]}
N 860 -3550 860 -3760 {lab=inv_vin}
N 770 -3300 770 -3240 {lab=analog_PAD[3]}
N 997.5 -3540 997.5 -3590 {lab=VSS}
N 1007.5 -3530 1007.5 -3620 {lab=VDD}
N 1017.5 -3520 1017.5 -3650 {lab=IOVSS}
N 1030 -3510 1030 -3680 {lab=IOVDD}
N 1090 -3550 1090 -3760 {lab=analog_PAD[4]}
N 1190 -3550 1190 -3760 {lab=open_inv_vout_pad_padres}
N 1100 -3300 1100 -3240 {lab=analog_PAD[4]}
N 1350 -3540 1350 -3590 {lab=VSS}
N 1360 -3530 1360 -3620 {lab=VDD}
N 1370 -3520 1370 -3650 {lab=IOVSS}
N 1380 -3510 1380 -3680 {lab=IOVDD}
N 1520 -3550 1520 -3760 {lab=inv_dout}
N 1430 -3300 1430 -3240 {lab=output_PAD[7]}
N 1657.5 -3540 1657.5 -3590 {lab=VSS}
N 1667.5 -3530 1667.5 -3620 {lab=VDD}
N 1677.5 -3520 1677.5 -3650 {lab=IOVSS}
N 1690 -3510 1690 -3680 {lab=IOVDD}
N 1750 -3550 1750 -3760 {lab=vdd_ro_PAD}
N 1850 -3550 1850 -3760 {lab=open_vdd_ro_pad_padres}
N 1760 -3300 1760 -3240 {lab=vdd_ro_PAD}
N 1987.5 -3540 1987.5 -3590 {lab=VSS}
N 1997.5 -3530 1997.5 -3620 {lab=VDD}
N 2007.5 -3520 2007.5 -3650 {lab=IOVSS}
N 2020 -3510 2020 -3680 {lab=IOVDD}
N 2080 -3550 2080 -3760 {lab=analog_PAD[5]}
N 2180 -3550 2180 -3760 {lab=open_ro_vout_pad_padres}
N 2090 -3300 2090 -3240 {lab=analog_PAD[5]}
N 2317.5 -3540 2317.5 -3590 {lab=VSS}
N 2327.5 -3530 2327.5 -3620 {lab=VDD}
N 2337.5 -3520 2337.5 -3650 {lab=IOVSS}
N 2350 -3510 2350 -3680 {lab=IOVDD}
N 2410 -3550 2410 -3760 {lab=vdd_hv_PAD}
N 2510 -3550 2510 -3760 {lab=open_vdd_hv_pad_padres}
N 2420 -3300 2420 -3240 {lab=vdd_hv_PAD}
N -30 -3590 2570 -3590 {lab=VSS}
N -30 -3620 2570 -3620 {lab=VDD}
N -30 -3650 2570 -3650 {lab=IOVSS}
N -30 -3680 2570 -3680 {lab=IOVDD}
N 30 -2740 30 -2790 {lab=VSS}
N 40 -2730 40 -2820 {lab=VDD}
N 50 -2720 50 -2850 {lab=IOVSS}
N 60 -2710 60 -2880 {lab=IOVDD}
N 200 -2750 200 -2960 {lab=count[0]}
N 110 -2500 110 -2440 {lab=output_PAD[0]}
N 360 -2740 360 -2790 {lab=VSS}
N 370 -2730 370 -2820 {lab=VDD}
N 380 -2720 380 -2850 {lab=IOVSS}
N 390 -2710 390 -2880 {lab=IOVDD}
N 530 -2750 530 -2960 {lab=count[1]}
N 440 -2500 440 -2440 {lab=output_PAD[1]}
N 690 -2740 690 -2790 {lab=VSS}
N 700 -2730 700 -2820 {lab=VDD}
N 710 -2720 710 -2850 {lab=IOVSS}
N 720 -2710 720 -2880 {lab=IOVDD}
N 860 -2750 860 -2960 {lab=count[2]}
N 770 -2500 770 -2440 {lab=output_PAD[2]}
N 1020 -2740 1020 -2790 {lab=VSS}
N 1030 -2730 1030 -2820 {lab=VDD}
N 1040 -2720 1040 -2850 {lab=IOVSS}
N 1050 -2710 1050 -2880 {lab=IOVDD}
N 1190 -2750 1190 -2960 {lab=count[3]}
N 1100 -2500 1100 -2440 {lab=output_PAD[3]}
N 1350 -2740 1350 -2790 {lab=VSS}
N 1360 -2730 1360 -2820 {lab=VDD}
N 1370 -2720 1370 -2850 {lab=IOVSS}
N 1380 -2710 1380 -2880 {lab=IOVDD}
N 1520 -2750 1520 -2960 {lab=count[4]}
N 1430 -2500 1430 -2440 {lab=output_PAD[4]}
N 1680 -2740 1680 -2790 {lab=VSS}
N 1690 -2730 1690 -2820 {lab=VDD}
N 1700 -2720 1700 -2850 {lab=IOVSS}
N 1710 -2710 1710 -2880 {lab=IOVDD}
N 1850 -2750 1850 -2960 {lab=count[5]}
N 1760 -2500 1760 -2440 {lab=output_PAD[5]}
N 2010 -2740 2010 -2790 {lab=VSS}
N 2020 -2730 2020 -2820 {lab=VDD}
N 2030 -2720 2030 -2850 {lab=IOVSS}
N 2040 -2710 2040 -2880 {lab=IOVDD}
N 2180 -2750 2180 -2960 {lab=count[6]}
N 2090 -2500 2090 -2440 {lab=output_PAD[6]}
N 2400 -2740 2400 -2790 {lab=VSS}
N 2410 -2730 2410 -2820 {lab=VDD}
N 2420 -2720 2420 -2850 {lab=IOVSS}
N 2430 -2710 2430 -2880 {lab=IOVDD}
N 2320 -2760 2320 -2960 {lab=inv_din}
N 2510 -2750 2510 -2960 {lab=count[7]}
N 2500 -2760 2500 -2960 {lab=tie_hi}
N 2420 -2500 2420 -2440 {lab=bidir_PAD}
N -30 -2790 2570 -2790 {lab=VSS}
N -30 -2820 2570 -2820 {lab=VDD}
N -30 -2850 2570 -2850 {lab=IOVSS}
N -30 -2880 2570 -2880 {lab=IOVDD}
N 160 -1800 120 -1800 {lab=sel0}
N 240 -1800 280 -1800 {lab=sel0_b}
N 160 -1600 120 -1600 {lab=sel1}
N 240 -1600 280 -1600 {lab=sel1_b}
N 640 -1820 600 -1820 {lab=sel1_b}
N 640 -1780 600 -1780 {lab=sel0}
N 760 -1800 800 -1800 {lab=sel_lv_ihp}
N 640 -1620 600 -1620 {lab=sel1}
N 640 -1580 600 -1580 {lab=sel0_b}
N 760 -1600 800 -1600 {lab=sel_hv_ihp}
N 640 -1420 600 -1420 {lab=sel1}
N 640 -1380 600 -1380 {lab=sel0}
N 760 -1400 800 -1400 {lab=sel_lv_eth}
N 1140 -1820 1100 -1820 {lab=clk}
N 1140 -1780 1100 -1780 {lab=sel_lv_ihp}
N 1260 -1800 1300 -1800 {lab=clk_lv_ihp}
N 1140 -1620 1100 -1620 {lab=clk}
N 1140 -1580 1100 -1580 {lab=sel_hv_ihp}
N 1260 -1600 1300 -1600 {lab=clk_hv_ihp}
N 1140 -1420 1100 -1420 {lab=clk}
N 1140 -1380 1100 -1380 {lab=sel_lv_eth}
N 1260 -1400 1300 -1400 {lab=clk_lv_eth}
N 200 -1400 240 -1400 {lab=tie_hi}
N 200 -1280 240 -1280 {lab=tie_lo}
N 1660 -1710 1620 -1710 {lab=tie_lo}
N 1660 -1670 1620 -1670 {lab=count_lv_ihp0}
N 1660 -1630 1620 -1630 {lab=count_hv_ihp0}
N 1660 -1590 1620 -1590 {lab=count_lv_eth0}
N 1660 -1550 1620 -1550 {lab=sel0}
N 1660 -1520 1620 -1520 {lab=sel1}
N 1740 -1650 1780 -1650 {lab=count[0]}
N 2040 -1710 2000 -1710 {lab=tie_lo}
N 2040 -1670 2000 -1670 {lab=count_lv_ihp1}
N 2040 -1630 2000 -1630 {lab=count_hv_ihp1}
N 2040 -1590 2000 -1590 {lab=count_lv_eth1}
N 2040 -1550 2000 -1550 {lab=sel0}
N 2040 -1520 2000 -1520 {lab=sel1}
N 2120 -1650 2160 -1650 {lab=count[1]}
N 2420 -1710 2380 -1710 {lab=tie_lo}
N 2420 -1670 2380 -1670 {lab=count_lv_ihp2}
N 2420 -1630 2380 -1630 {lab=count_hv_ihp2}
N 2420 -1590 2380 -1590 {lab=count_lv_eth2}
N 2420 -1550 2380 -1550 {lab=sel0}
N 2420 -1520 2380 -1520 {lab=sel1}
N 2500 -1650 2540 -1650 {lab=count[2]}
N 2800 -1710 2760 -1710 {lab=tie_lo}
N 2800 -1670 2760 -1670 {lab=count_lv_ihp3}
N 2800 -1630 2760 -1630 {lab=count_hv_ihp3}
N 2800 -1590 2760 -1590 {lab=count_lv_eth3}
N 2800 -1550 2760 -1550 {lab=sel0}
N 2800 -1520 2760 -1520 {lab=sel1}
N 2880 -1650 2920 -1650 {lab=count[3]}
N 3180 -1710 3140 -1710 {lab=tie_lo}
N 3180 -1670 3140 -1670 {lab=count_lv_ihp4}
N 3180 -1630 3140 -1630 {lab=count_hv_ihp4}
N 3180 -1590 3140 -1590 {lab=count_lv_eth4}
N 3180 -1550 3140 -1550 {lab=sel0}
N 3180 -1520 3140 -1520 {lab=sel1}
N 3260 -1650 3300 -1650 {lab=count[4]}
N 3560 -1710 3520 -1710 {lab=tie_lo}
N 3560 -1670 3520 -1670 {lab=count_lv_ihp5}
N 3560 -1630 3520 -1630 {lab=count_hv_ihp5}
N 3560 -1590 3520 -1590 {lab=count_lv_eth5}
N 3560 -1550 3520 -1550 {lab=sel0}
N 3560 -1520 3520 -1520 {lab=sel1}
N 3640 -1650 3680 -1650 {lab=count[5]}
N 3940 -1710 3900 -1710 {lab=tie_lo}
N 3940 -1670 3900 -1670 {lab=count_lv_ihp6}
N 3940 -1630 3900 -1630 {lab=count_hv_ihp6}
N 3940 -1590 3900 -1590 {lab=count_lv_eth6}
N 3940 -1550 3900 -1550 {lab=sel0}
N 3940 -1520 3900 -1520 {lab=sel1}
N 4020 -1650 4060 -1650 {lab=count[6]}
N 4320 -1710 4280 -1710 {lab=tie_lo}
N 4320 -1670 4280 -1670 {lab=count_lv_ihp7}
N 4320 -1630 4280 -1630 {lab=count_hv_ihp7}
N 4320 -1590 4280 -1590 {lab=count_lv_eth7}
N 4320 -1550 4280 -1550 {lab=sel0}
N 4320 -1520 4280 -1520 {lab=sel1}
N 4400 -1650 4440 -1650 {lab=count[7]}
N 300 -950 340 -950 {lab=VDD}
N 300 -750 340 -750 {lab=VSS}
N 200 -910 160 -910 {lab=clk_lv_ihp}
N 200 -790 160 -790 {lab=rst_n}
N 200 -850 160 -850 {lab=sel_lv_ihp}
N 400 -850 440 -850 {lab=count_lv_ihp[0..7]}
N 1000 -950 1040 -950 {lab=VDD}
N 1000 -750 1040 -750 {lab=VSS}
N 900 -910 860 -910 {lab=clk_lv_eth}
N 900 -790 860 -790 {lab=rst_n}
N 900 -850 860 -850 {lab=sel_lv_eth}
N 1100 -850 1140 -850 {lab=count_lv_eth[0..7]}
N 1700 -950 1740 -950 {lab=vdd_hv_PAD}
N 1700 -750 1740 -750 {lab=VSS}
N 1600 -910 1560 -910 {lab=clk_hv_ihp}
N 1600 -790 1560 -790 {lab=rst_n}
N 1600 -850 1560 -850 {lab=sel_hv_ihp}
N 1800 -850 1840 -850 {lab=count_hv_ihp[0..7]}
N 300 -490 340 -490 {lab=VDD}
N 180 -410 140 -410 {lab=inv_din}
N 420 -410 460 -410 {lab=inv_dout}
N 300 -210 340 -210 {lab=VSS}
N 180 -370 140 -370 {lab=VSS}
N 420 -370 460 -370 {lab=open_x_inverter_vout3}
N 180 -330 140 -330 {lab=VSS}
N 420 -330 460 -330 {lab=open_x_inverter_vout2}
N 420 -290 460 -290 {lab=analog_PAD[4]}
N 180 -290 140 -290 {lab=inv_vin}
N 1000 -410 960 -410 {lab=VDD}
N 940 -350 900 -350 {lab=amp_vin}
N 1080 -350 1120 -350 {lab=analog_PAD[2]}
N 1000 -290 960 -290 {lab=VSS}
N 1820 -350 1860 -350 {lab=analog_PAD[5]}
N 1700 -410 1660 -410 {lab=vdd_ro_PAD}
N 1700 -290 1660 -290 {lab=VSS}
N 2540 -530 2580 -530 {lab=di_en}
N 2600 -530 2640 -530 {lab=vdd_rf_PAD}
N 2600 -330 2640 -330 {lab=VSS}
N 2380 -430 2340 -430 {lab=vtune}
N 2660 -450 2700 -450 {lab=rf_PAD[1]}
N 2660 -410 2700 -410 {lab=rf_PAD[0]}
C {sg13cmos5l_io/sg13cmos5l_IOPadIn.sym} 0 -4800 0 0 {name=x_clk_pad}
C {lab_pin.sym} 200 -5360 1 1 {name=p1 sig_type=std_logic lab=clk}
C {devices/ipin.sym} 110 -4840 1 0 {name=pin_clk_pad lab=clk_PAD}
C {sg13cmos5l_io/sg13cmos5l_IOPadIn.sym} 330 -4800 0 0 {name=x_rst_n_pad}
C {lab_pin.sym} 530 -5360 1 1 {name=p2 sig_type=std_logic lab=rst_n}
C {devices/ipin.sym} 440 -4840 1 0 {name=pin_rst_n_pad lab=rst_n_PAD}
C {sg13cmos5l_io/sg13cmos5l_IOPadIn.sym} 660 -4800 0 0 {name=x_sel1_pad}
C {lab_pin.sym} 860 -5360 1 1 {name=p3 sig_type=std_logic lab=sel1}
C {devices/ipin.sym} 770 -4840 1 0 {name=pin_sel1_pad lab=input_PAD[1]}
C {sg13cmos5l_io/sg13cmos5l_IOPadIn.sym} 990 -4800 0 0 {name=x_sel0_pad}
C {lab_pin.sym} 1190 -5360 1 1 {name=p4 sig_type=std_logic lab=sel0}
C {devices/ipin.sym} 1100 -4840 1 0 {name=pin_sel0_pad lab=input_PAD[0]}
C {sg13cmos5l_io/sg13cmos5l_IOPadIOVdd.sym} 1320 -4800 0 0 {name=x_iovdd_pad}
C {devices/iopin.sym} 1430 -4840 1 0 {name=pin_iovdd_pad lab=IOVDD}
C {sg13cmos5l_io/sg13cmos5l_IOPadIOVss.sym} 1650 -4800 0 0 {name=x_iovss_pad}
C {devices/iopin.sym} 1760 -4840 1 0 {name=pin_iovss_pad lab=IOVSS}
C {sg13cmos5l_io/sg13cmos5l_IOPadVdd.sym} 1980 -4800 0 0 {name=x_vdd_pad}
C {devices/iopin.sym} 2090 -4840 1 0 {name=pin_vdd_pad lab=VDD}
C {sg13cmos5l_io/sg13cmos5l_IOPadVss.sym} 2310 -4800 0 0 {name=x_vss_pad0}
C {devices/iopin.sym} 2420 -4840 1 0 {name=pin_vss_pad0 lab=VSS}
C {lab_pin.sym} -30 -5190 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -30 -5220 0 0 {name=p6 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 -5250 0 0 {name=p7 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} -30 -5280 0 0 {name=p8 sig_type=std_logic lab=IOVDD}
C {sg13cmos5l_io/sg13cmos5l_IOPadIn.sym} 0 -4000 0 0 {name=x_di_en_pad}
C {lab_pin.sym} 200 -4560 1 1 {name=p9 sig_type=std_logic lab=di_en}
C {devices/ipin.sym} 110 -4040 1 0 {name=pin_di_en_pad lab=input_PAD[2]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 330 -4000 0 0 {name=x_vtune_pad}
C {lab_pin.sym} 430 -4560 1 1 {name=p10 sig_type=std_logic lab=analog_PAD[0]}
C {lab_pin.sym} 530 -4560 1 1 {name=p11 sig_type=std_logic lab=vtune}
C {devices/iopin.sym} 440 -4040 1 0 {name=pin_vtune_pad lab=analog_PAD[0]}
C {sg13cmos5l_io/sg13cmos5l_IOPadVss.sym} 660 -4000 0 0 {name=x_vss_pad1}
C {lab_pin.sym} 770 -4040 1 1 {name=p12 sig_type=std_logic lab=VSS}
C {sg13cmos5l_ip__rfpad_70x70.sym} 1090 -4200 0 0 {name=x_rf_n_pad}
C {lab_pin.sym} 1010 -4120 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1010 -4280 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1170 -4120 2 0 {name=p15 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} 1170 -4280 2 0 {name=p16 sig_type=std_logic lab=IOVDD}
C {lab_pin.sym} 1230 -4200 2 0 {name=p17 sig_type=std_logic lab=rf_PAD[0]}
C {devices/iopin.sym} 1090 -4040 1 0 {name=pin_rf_n_pad lab=rf_PAD[0]}
C {sg13cmos5l_ip__rfpad_70x70.sym} 1420 -4200 0 0 {name=x_rf_p_pad}
C {lab_pin.sym} 1340 -4120 0 0 {name=p18 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1340 -4280 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1500 -4120 2 0 {name=p20 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} 1500 -4280 2 0 {name=p21 sig_type=std_logic lab=IOVDD}
C {lab_pin.sym} 1560 -4200 2 0 {name=p22 sig_type=std_logic lab=rf_PAD[1]}
C {devices/iopin.sym} 1420 -4040 1 0 {name=pin_rf_p_pad lab=rf_PAD[1]}
C {sg13cmos5l_io/sg13cmos5l_IOPadVss.sym} 1650 -4000 0 0 {name=x_vss_pad2}
C {lab_pin.sym} 1760 -4040 1 1 {name=p23 sig_type=std_logic lab=VSS}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 1980 -4000 0 0 {name=x_vdd_rf_pad}
C {lab_pin.sym} 2080 -4560 1 1 {name=p24 sig_type=std_logic lab=vdd_rf_PAD}
C {noconn.sym} 2180 -4560 0 0 {name=l25}
C {devices/iopin.sym} 2090 -4040 1 0 {name=pin_vdd_rf_pad lab=vdd_rf_PAD}
C {sg13cmos5l_io/sg13cmos5l_IOPadVss.sym} 2310 -4000 0 0 {name=x_vss_pad3}
C {lab_pin.sym} 2420 -4040 1 1 {name=p26 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -30 -4390 0 0 {name=p27 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -30 -4420 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 -4450 0 0 {name=p29 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} -30 -4480 0 0 {name=p30 sig_type=std_logic lab=IOVDD}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 0 -3200 0 0 {name=x_amp_vin_pad}
C {lab_pin.sym} 100 -3760 1 1 {name=p31 sig_type=std_logic lab=analog_PAD[1]}
C {lab_pin.sym} 200 -3760 1 1 {name=p32 sig_type=std_logic lab=amp_vin}
C {devices/iopin.sym} 110 -3240 1 0 {name=pin_amp_vin_pad lab=analog_PAD[1]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 330 -3200 0 0 {name=x_amp_vout_pad}
C {lab_pin.sym} 430 -3760 1 1 {name=p33 sig_type=std_logic lab=analog_PAD[2]}
C {noconn.sym} 530 -3760 0 0 {name=l34}
C {devices/iopin.sym} 440 -3240 1 0 {name=pin_amp_vout_pad lab=analog_PAD[2]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 660 -3200 0 0 {name=x_inv_vin_pad}
C {lab_pin.sym} 760 -3760 1 1 {name=p35 sig_type=std_logic lab=analog_PAD[3]}
C {lab_pin.sym} 860 -3760 1 1 {name=p36 sig_type=std_logic lab=inv_vin}
C {devices/iopin.sym} 770 -3240 1 0 {name=pin_inv_vin_pad lab=analog_PAD[3]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 990 -3200 0 0 {name=x_inv_vout_pad}
C {lab_pin.sym} 1090 -3760 1 1 {name=p37 sig_type=std_logic lab=analog_PAD[4]}
C {noconn.sym} 1190 -3760 0 0 {name=l38}
C {devices/iopin.sym} 1100 -3240 1 0 {name=pin_inv_vout_pad lab=analog_PAD[4]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 1320 -3200 0 0 {name=x_inv_dout_pad}
C {lab_pin.sym} 1520 -3760 1 1 {name=p39 sig_type=std_logic lab=inv_dout}
C {devices/opin.sym} 1430 -3240 1 0 {name=pin_inv_dout_pad lab=output_PAD[7]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 1650 -3200 0 0 {name=x_vdd_ro_pad}
C {lab_pin.sym} 1750 -3760 1 1 {name=p40 sig_type=std_logic lab=vdd_ro_PAD}
C {noconn.sym} 1850 -3760 0 0 {name=l41}
C {devices/iopin.sym} 1760 -3240 1 0 {name=pin_vdd_ro_pad lab=vdd_ro_PAD}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 1980 -3200 0 0 {name=x_ro_vout_pad}
C {lab_pin.sym} 2080 -3760 1 1 {name=p42 sig_type=std_logic lab=analog_PAD[5]}
C {noconn.sym} 2180 -3760 0 0 {name=l43}
C {devices/iopin.sym} 2090 -3240 1 0 {name=pin_ro_vout_pad lab=analog_PAD[5]}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 2310 -3200 0 0 {name=x_vdd_hv_pad}
C {lab_pin.sym} 2410 -3760 1 1 {name=p44 sig_type=std_logic lab=vdd_hv_PAD}
C {noconn.sym} 2510 -3760 0 0 {name=l45}
C {devices/iopin.sym} 2420 -3240 1 0 {name=pin_vdd_hv_pad lab=vdd_hv_PAD}
C {lab_pin.sym} -30 -3590 0 0 {name=p46 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -30 -3620 0 0 {name=p47 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 -3650 0 0 {name=p48 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} -30 -3680 0 0 {name=p49 sig_type=std_logic lab=IOVDD}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 0 -2400 0 0 {name=x_count0_pad}
C {lab_pin.sym} 200 -2960 1 1 {name=p50 sig_type=std_logic lab=count[0]}
C {devices/opin.sym} 110 -2440 1 0 {name=pin_count0_pad lab=output_PAD[0]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 330 -2400 0 0 {name=x_count1_pad}
C {lab_pin.sym} 530 -2960 1 1 {name=p51 sig_type=std_logic lab=count[1]}
C {devices/opin.sym} 440 -2440 1 0 {name=pin_count1_pad lab=output_PAD[1]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 660 -2400 0 0 {name=x_count2_pad}
C {lab_pin.sym} 860 -2960 1 1 {name=p52 sig_type=std_logic lab=count[2]}
C {devices/opin.sym} 770 -2440 1 0 {name=pin_count2_pad lab=output_PAD[2]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 990 -2400 0 0 {name=x_count3_pad}
C {lab_pin.sym} 1190 -2960 1 1 {name=p53 sig_type=std_logic lab=count[3]}
C {devices/opin.sym} 1100 -2440 1 0 {name=pin_count3_pad lab=output_PAD[3]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 1320 -2400 0 0 {name=x_count4_pad}
C {lab_pin.sym} 1520 -2960 1 1 {name=p54 sig_type=std_logic lab=count[4]}
C {devices/opin.sym} 1430 -2440 1 0 {name=pin_count4_pad lab=output_PAD[4]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 1650 -2400 0 0 {name=x_count5_pad}
C {lab_pin.sym} 1850 -2960 1 1 {name=p55 sig_type=std_logic lab=count[5]}
C {devices/opin.sym} 1760 -2440 1 0 {name=pin_count5_pad lab=output_PAD[5]}
C {sg13cmos5l_io/sg13cmos5l_IOPadOut16mA.sym} 1980 -2400 0 0 {name=x_count6_pad}
C {lab_pin.sym} 2180 -2960 1 1 {name=p56 sig_type=std_logic lab=count[6]}
C {devices/opin.sym} 2090 -2440 1 0 {name=pin_count6_pad lab=output_PAD[6]}
C {sg13cmos5l_io/sg13cmos5l_IOPadInOut16mA.sym} 2310 -2400 0 0 {name=x_count7_pad}
C {lab_pin.sym} 2320 -2960 1 1 {name=p57 sig_type=std_logic lab=inv_din}
C {lab_pin.sym} 2510 -2960 1 1 {name=p58 sig_type=std_logic lab=count[7]}
C {lab_pin.sym} 2500 -2960 1 1 {name=p59 sig_type=std_logic lab=tie_hi}
C {devices/iopin.sym} 2420 -2440 1 0 {name=pin_count7_pad lab=bidir_PAD}
C {lab_pin.sym} -30 -2790 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -30 -2820 0 0 {name=p61 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 -2850 0 0 {name=p62 sig_type=std_logic lab=IOVSS}
C {lab_pin.sym} -30 -2880 0 0 {name=p63 sig_type=std_logic lab=IOVDD}
C {sg13cmos5l_stdcells/sg13cmos5l_inv_1.sym} 200 -1800 0 0 {name=x_sel0_b VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 120 -1800 0 0 {name=p64 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 280 -1800 2 0 {name=p65 sig_type=std_logic lab=sel0_b}
C {sg13cmos5l_stdcells/sg13cmos5l_inv_1.sym} 200 -1600 0 0 {name=x_sel1_b VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 120 -1600 0 0 {name=p66 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 280 -1600 2 0 {name=p67 sig_type=std_logic lab=sel1_b}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 700 -1800 0 0 {name=x_sel_lv_ihp VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 600 -1820 0 0 {name=p68 sig_type=std_logic lab=sel1_b}
C {lab_pin.sym} 600 -1780 0 0 {name=p69 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 800 -1800 2 0 {name=p70 sig_type=std_logic lab=sel_lv_ihp}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 700 -1600 0 0 {name=x_sel_hv_ihp VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 600 -1620 0 0 {name=p71 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 600 -1580 0 0 {name=p72 sig_type=std_logic lab=sel0_b}
C {lab_pin.sym} 800 -1600 2 0 {name=p73 sig_type=std_logic lab=sel_hv_ihp}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 700 -1400 0 0 {name=x_sel_lv_eth VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 600 -1420 0 0 {name=p74 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 600 -1380 0 0 {name=p75 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 800 -1400 2 0 {name=p76 sig_type=std_logic lab=sel_lv_eth}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 1200 -1800 0 0 {name=x_clk_lv_ihp VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 1100 -1820 0 0 {name=p77 sig_type=std_logic lab=clk}
C {lab_pin.sym} 1100 -1780 0 0 {name=p78 sig_type=std_logic lab=sel_lv_ihp}
C {lab_pin.sym} 1300 -1800 2 0 {name=p79 sig_type=std_logic lab=clk_lv_ihp}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 1200 -1600 0 0 {name=x_clk_hv_ihp VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 1100 -1620 0 0 {name=p80 sig_type=std_logic lab=clk}
C {lab_pin.sym} 1100 -1580 0 0 {name=p81 sig_type=std_logic lab=sel_hv_ihp}
C {lab_pin.sym} 1300 -1600 2 0 {name=p82 sig_type=std_logic lab=clk_hv_ihp}
C {sg13cmos5l_stdcells/sg13cmos5l_and2_1.sym} 1200 -1400 0 0 {name=x_clk_lv_eth VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 1100 -1420 0 0 {name=p83 sig_type=std_logic lab=clk}
C {lab_pin.sym} 1100 -1380 0 0 {name=p84 sig_type=std_logic lab=sel_lv_eth}
C {lab_pin.sym} 1300 -1400 2 0 {name=p85 sig_type=std_logic lab=clk_lv_eth}
C {sg13cmos5l_stdcells/sg13cmos5l_tiehi.sym} 200 -1400 0 0 {name=x_tie_hi VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 240 -1400 2 0 {name=p86 sig_type=std_logic lab=tie_hi}
C {sg13cmos5l_stdcells/sg13cmos5l_tielo.sym} 200 -1280 0 0 {name=x_tie_lo VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 240 -1280 2 0 {name=p87 sig_type=std_logic lab=tie_lo}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 1700 -1650 0 0 {name=x_count_mux0 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 1620 -1710 0 0 {name=p88 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 1620 -1670 0 0 {name=p89 sig_type=std_logic lab=count_lv_ihp0}
C {lab_pin.sym} 1620 -1630 0 0 {name=p90 sig_type=std_logic lab=count_hv_ihp0}
C {lab_pin.sym} 1620 -1590 0 0 {name=p91 sig_type=std_logic lab=count_lv_eth0}
C {lab_pin.sym} 1620 -1550 0 0 {name=p92 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 1620 -1520 0 0 {name=p93 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 1780 -1650 2 0 {name=p94 sig_type=std_logic lab=count[0]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 2080 -1650 0 0 {name=x_count_mux1 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 2000 -1710 0 0 {name=p95 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 2000 -1670 0 0 {name=p96 sig_type=std_logic lab=count_lv_ihp1}
C {lab_pin.sym} 2000 -1630 0 0 {name=p97 sig_type=std_logic lab=count_hv_ihp1}
C {lab_pin.sym} 2000 -1590 0 0 {name=p98 sig_type=std_logic lab=count_lv_eth1}
C {lab_pin.sym} 2000 -1550 0 0 {name=p99 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 2000 -1520 0 0 {name=p100 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 2160 -1650 2 0 {name=p101 sig_type=std_logic lab=count[1]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 2460 -1650 0 0 {name=x_count_mux2 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 2380 -1710 0 0 {name=p102 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 2380 -1670 0 0 {name=p103 sig_type=std_logic lab=count_lv_ihp2}
C {lab_pin.sym} 2380 -1630 0 0 {name=p104 sig_type=std_logic lab=count_hv_ihp2}
C {lab_pin.sym} 2380 -1590 0 0 {name=p105 sig_type=std_logic lab=count_lv_eth2}
C {lab_pin.sym} 2380 -1550 0 0 {name=p106 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 2380 -1520 0 0 {name=p107 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 2540 -1650 2 0 {name=p108 sig_type=std_logic lab=count[2]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 2840 -1650 0 0 {name=x_count_mux3 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 2760 -1710 0 0 {name=p109 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 2760 -1670 0 0 {name=p110 sig_type=std_logic lab=count_lv_ihp3}
C {lab_pin.sym} 2760 -1630 0 0 {name=p111 sig_type=std_logic lab=count_hv_ihp3}
C {lab_pin.sym} 2760 -1590 0 0 {name=p112 sig_type=std_logic lab=count_lv_eth3}
C {lab_pin.sym} 2760 -1550 0 0 {name=p113 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 2760 -1520 0 0 {name=p114 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 2920 -1650 2 0 {name=p115 sig_type=std_logic lab=count[3]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 3220 -1650 0 0 {name=x_count_mux4 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 3140 -1710 0 0 {name=p116 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 3140 -1670 0 0 {name=p117 sig_type=std_logic lab=count_lv_ihp4}
C {lab_pin.sym} 3140 -1630 0 0 {name=p118 sig_type=std_logic lab=count_hv_ihp4}
C {lab_pin.sym} 3140 -1590 0 0 {name=p119 sig_type=std_logic lab=count_lv_eth4}
C {lab_pin.sym} 3140 -1550 0 0 {name=p120 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 3140 -1520 0 0 {name=p121 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 3300 -1650 2 0 {name=p122 sig_type=std_logic lab=count[4]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 3600 -1650 0 0 {name=x_count_mux5 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 3520 -1710 0 0 {name=p123 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 3520 -1670 0 0 {name=p124 sig_type=std_logic lab=count_lv_ihp5}
C {lab_pin.sym} 3520 -1630 0 0 {name=p125 sig_type=std_logic lab=count_hv_ihp5}
C {lab_pin.sym} 3520 -1590 0 0 {name=p126 sig_type=std_logic lab=count_lv_eth5}
C {lab_pin.sym} 3520 -1550 0 0 {name=p127 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 3520 -1520 0 0 {name=p128 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 3680 -1650 2 0 {name=p129 sig_type=std_logic lab=count[5]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 3980 -1650 0 0 {name=x_count_mux6 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 3900 -1710 0 0 {name=p130 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 3900 -1670 0 0 {name=p131 sig_type=std_logic lab=count_lv_ihp6}
C {lab_pin.sym} 3900 -1630 0 0 {name=p132 sig_type=std_logic lab=count_hv_ihp6}
C {lab_pin.sym} 3900 -1590 0 0 {name=p133 sig_type=std_logic lab=count_lv_eth6}
C {lab_pin.sym} 3900 -1550 0 0 {name=p134 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 3900 -1520 0 0 {name=p135 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 4060 -1650 2 0 {name=p136 sig_type=std_logic lab=count[6]}
C {sg13cmos5l_stdcells/sg13cmos5l_mux4_1.sym} 4360 -1650 0 0 {name=x_count_mux7 VDD=VDD VSS=VSS prefix=sg13cmos5l_}
C {lab_pin.sym} 4280 -1710 0 0 {name=p137 sig_type=std_logic lab=tie_lo}
C {lab_pin.sym} 4280 -1670 0 0 {name=p138 sig_type=std_logic lab=count_lv_ihp7}
C {lab_pin.sym} 4280 -1630 0 0 {name=p139 sig_type=std_logic lab=count_hv_ihp7}
C {lab_pin.sym} 4280 -1590 0 0 {name=p140 sig_type=std_logic lab=count_lv_eth7}
C {lab_pin.sym} 4280 -1550 0 0 {name=p141 sig_type=std_logic lab=sel0}
C {lab_pin.sym} 4280 -1520 0 0 {name=p142 sig_type=std_logic lab=sel1}
C {lab_pin.sym} 4440 -1650 2 0 {name=p143 sig_type=std_logic lab=count[7]}
C {counter_lv_ihp_top.sym} 300 -850 0 0 {name=x_counter_lv_ihp}
C {lab_pin.sym} 340 -950 2 0 {name=p144 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 340 -750 2 0 {name=p145 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 160 -910 0 0 {name=p146 sig_type=std_logic lab=clk_lv_ihp}
C {lab_pin.sym} 160 -790 0 0 {name=p147 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} 160 -850 0 0 {name=p148 sig_type=std_logic lab=sel_lv_ihp}
C {lab_pin.sym} 440 -850 2 0 {name=p149 sig_type=std_logic lab=count_lv_ihp[0..7]}
C {counter_lv_eth_top_pex.sym} 1000 -850 0 0 {name=x_counter_lv_eth}
C {lab_pin.sym} 1040 -950 2 0 {name=p150 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1040 -750 2 0 {name=p151 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 860 -910 0 0 {name=p152 sig_type=std_logic lab=clk_lv_eth}
C {lab_pin.sym} 860 -790 0 0 {name=p153 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} 860 -850 0 0 {name=p154 sig_type=std_logic lab=sel_lv_eth}
C {lab_pin.sym} 1140 -850 2 0 {name=p155 sig_type=std_logic lab=count_lv_eth[0..7]}
C {counter_hv_kvc_top_pex.sym} 1700 -850 0 0 {name=x_counter_hv_kvc}
C {lab_pin.sym} 1740 -950 2 0 {name=p156 sig_type=std_logic lab=vdd_hv_PAD}
C {lab_pin.sym} 1740 -750 2 0 {name=p157 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1560 -910 0 0 {name=p158 sig_type=std_logic lab=clk_hv_ihp}
C {lab_pin.sym} 1560 -790 0 0 {name=p159 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} 1560 -850 0 0 {name=p160 sig_type=std_logic lab=sel_hv_ihp}
C {lab_pin.sym} 1840 -850 2 0 {name=p161 sig_type=std_logic lab=count_hv_ihp[0..7]}
C {inverter_top.sym} 300 -350 0 0 {name=x_inverter}
C {lab_pin.sym} 340 -490 2 0 {name=p162 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 140 -410 0 0 {name=p163 sig_type=std_logic lab=inv_din}
C {lab_pin.sym} 460 -410 2 0 {name=p164 sig_type=std_logic lab=inv_dout}
C {lab_pin.sym} 340 -210 2 0 {name=p165 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 140 -370 0 0 {name=p166 sig_type=std_logic lab=VSS}
C {noconn.sym} 460 -370 0 0 {name=l167}
C {lab_pin.sym} 140 -330 0 0 {name=p168 sig_type=std_logic lab=VSS}
C {noconn.sym} 460 -330 0 0 {name=l169}
C {lab_pin.sym} 460 -290 2 0 {name=p170 sig_type=std_logic lab=analog_PAD[4]}
C {lab_pin.sym} 140 -290 0 0 {name=p171 sig_type=std_logic lab=inv_vin}
C {amplifier.sym} 1000 -350 0 0 {name=x_amplifier}
C {lab_pin.sym} 960 -410 0 0 {name=p172 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 900 -350 0 0 {name=p173 sig_type=std_logic lab=amp_vin}
C {lab_pin.sym} 1120 -350 2 0 {name=p174 sig_type=std_logic lab=analog_PAD[2]}
C {lab_pin.sym} 960 -290 0 0 {name=p175 sig_type=std_logic lab=VSS}
C {ringosc.sym} 1700 -350 0 0 {name=x_ringosc}
C {lab_pin.sym} 1860 -350 2 0 {name=p176 sig_type=std_logic lab=analog_PAD[5]}
C {lab_pin.sym} 1660 -410 0 0 {name=p177 sig_type=std_logic lab=vdd_ro_PAD}
C {lab_pin.sym} 1660 -290 0 0 {name=p178 sig_type=std_logic lab=VSS}
C {vco_top.sym} 2400 -350 0 0 {name=x_vco}
C {lab_pin.sym} 2580 -530 2 0 {name=p179 sig_type=std_logic lab=di_en}
C {lab_pin.sym} 2640 -530 2 0 {name=p180 sig_type=std_logic lab=vdd_rf_PAD}
C {lab_pin.sym} 2640 -330 2 0 {name=p181 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2340 -430 0 0 {name=p182 sig_type=std_logic lab=vtune}
C {lab_pin.sym} 2700 -450 2 0 {name=p183 sig_type=std_logic lab=rf_PAD[1]}
C {lab_pin.sym} 2700 -410 2 0 {name=p184 sig_type=std_logic lab=rf_PAD[0]}
C {devices/title-2.sym} 0 0 0 0 {name=l_title author="Simon Dorrer" rev=1.0 lock=true}
