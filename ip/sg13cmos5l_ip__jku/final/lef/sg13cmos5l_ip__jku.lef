VERSION 5.8 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO sg13cmos5l_ip__jku
  CLASS BLOCK ;
  FOREIGN sg13cmos5l_ip__jku ;
  ORIGIN 0.000 0.000 ;
  SIZE 100 BY 100 ;
  OBS
      LAYER Metal4 ;
        RECT 0.0 0.0 100 100 ;
  END
END sg13cmos5l_ip__jku
END LIBRARY
